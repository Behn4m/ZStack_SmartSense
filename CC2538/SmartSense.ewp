# IAR project SmartSense.ewp, settings and files
configuration Coordinator (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_ZDO_CB_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; xZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_SCENES; ZCL_GROUPS; ZCL_ALARMS; xZCL_LEVEL_CTRL; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS; xHAL_PWM; xHAL_LED=FALSE
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: -f ..\Source\Tools\CC2538DB\f8wConfig.cfg; -f ..\Source\Tools\CC2538DB\f8wCoord.cfg; -f ..\Source\Tools\CC2538DB\f8wZCL.cfg
  ICCARM.CCIncludePath2: ..\Source; ..\Source; ..\Source\Zmain; ..\Source\Components\hal\include; ..\Source\Components\hal\target\CC2538; ..\Source\Components\driverlib\cc2538\inc; ..\Source\Components\driverlib\cc2538\source; ..\Source\Components\sdriverlib\cc2538\source; ..\Source\Components\bsp\srf06eb_cc2538\drivers\source; ..\Source\Components\mac\include; ..\Source\Components\mac\high_level; ..\Source\Components\mac\low_level\srf05\single_chip; ..\Source\Components\mac\low_level\srf05; ..\Source\Components\mt; ..\Source\Components\osal\include; ..\Source\Components\services\sdata; ..\Source\Components\services\saddr; ..\Source\Components\stack\af; ..\Source\Components\stack\nwk; ..\Source\Components\stack\sapi; ..\Source\Components\stack\sec; ..\Source\Components\stack\sys; ..\Source\Components\stack\zcl; ..\Source\Components\stack\zdo; ..\Source\Components\zmac; ..\Source\Components\zmac\f8w; ..\Source\EXT; ..\Source\EXT\SHT2x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: SmartSense.bin
  ILINK.IlinkOutputFile: SmartSense.out
  ILINK.IlinkIcfFile: ..\Source\Tools\CC2538DB\CC2538.icf
  ILINK.IlinkAdditionalLibs: ..\Source\Libraries\CC2538\bin\Router.a; ..\Source\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\Source\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\Source\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Router (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_ZDO_CB_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_SCENES; ZCL_GROUPS; xZCL_LEVEL_CTRL; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS; xHAL_PWM; xHAL_LED=FALSE
  ICCARM.IExtraOptions: -f ..\Source\Tools\CC2538DB\f8wConfig.cfg; -f ..\Source\Tools\CC2538DB\f8wRouter.cfg; -f ..\Source\Tools\CC2538DB\f8wZCL.cfg
configuration EndDevice (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; xNV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xHOLD_AUTO_START; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_ZDO_CB_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_SCENES; ZCL_GROUPS; ZCL_ALARMS; xZCL_LEVEL_CTRL; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS; xHAL_PWM; xHAL_LED=FALSE
  ICCARM.IExtraOptions: -f ..\Source\Tools\CC2538DB\f8wConfig.cfg; -f ..\Source\Tools\CC2538DB\f8wEndev.cfg; -f ..\Source\Tools\CC2538DB\f8wZCL.cfg
  ILINK.IlinkAdditionalLibs: ..\Source\Libraries\CC2538\bin\EndDevice.a; ..\Source\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\Source\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\Source\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  group Application
    ../Source/: OSAL_SmartSense.c zcl_SmartSense.c zcl_SmartSense.h zcl_SmartSense_data.c
  group HAL/Common
    ../Source/Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../Source/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/Drivers
    ../Source/Components/hal/target/CC2538/: hal_adc.c hal_aes.c hal_ccm.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.c hal_sleep.c hal_sys_ctrl.c hal_systick.c hal_timer.c hal_uart.c startup_ewarm.c
  group HAL/Target/Include
    ../Source/Components/hal/target/CC2538/: hal_aes.h hal_board_cfg.h hal_ccm.h hal_mac_cfg.h hal_mcu.h hal_sys_ctrl.h hal_systick.h hal_types.h iocc2538.h
  group HAL_EXT
    ../Source/EXT/: hal_i2c.c hal_i2c.h
  group MAC/High Level
    ../Source/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../Source/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../Source/Components/mac/low_level/srf05/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../Source/Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_radio_reg_defs.h mac_rffrontend.c
  group MT
    ../Source/Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../Source/Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../Source/Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../Source/Components/osal/mcu/cc2538/: armcm3flashutil.c armcm3flashutil.h osal_nv.c
    ../Source/Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../Source/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Profile
    ../Source/Components/stack/af/: AF.c AF.h
    ../Source/Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zcl_ms.c zcl_ms.h
    ../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../Source/Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../Source/Components/services/saddr/: saddr.c saddr.h
    ../Source/Components/services/sdata/: sdata.h
  group SHT2X
    ../Source/EXT/SHT2x/: SHT2x.c SHT2x.h Typesdef.h
  group Tools
    ../Source/Tools/CC2538DB/: CC2538.icf f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    ../Source/Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../Source/Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../Source/Components/zmac/: ZMAC.h
  group ZMain
    ../Source/ZMain/: OnBoard.c OnBoard.h ZMain.c
